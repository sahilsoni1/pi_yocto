FILESEXTRAPATHS:prepend := "${THISDIR}/linux-raspberrypi:"

SRC_URI:append = " file://bcm2835_codec.cfg"
